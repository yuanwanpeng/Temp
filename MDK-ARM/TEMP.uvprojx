# Keil uVision project TEMP.uvprojx, settings and files
target TEMP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TEMP +hex
  AfterMake: "D:\Program Files\Keil_v5\ARM\ARMCC\bin\fromelf.exe" --bin -o ./TEMP/TEMP.bin ./TEMP/TEMP.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\HARDWARE\LED;..\HARDWARE\BUTTON;..\HARDWARE\HUMI;..\HARDWARE\LCD12864;..\HARDWARE\RELAY;..\HARDWARE\24C0X;..\HARDWARE\DELAY;..\HARDWARE\BUZZER;..\HARDWARE\ESP8266;..\HARDWARE\DMA;..\Src;..\Drivers\EDP
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group HARDWARE
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/BUTTON/: button.c
    ../HARDWARE/LCD12864/: LCD12864.c TypeFace.c LCD12864_Display_Menu.c LCD12864_Display_Menu_Set_Strategy.c LCD12864_Display_Menu_Route_Reset.c LCD12864_Display_Menu_Max_Route.c LCD12864_Display_Menu_HUMI_Compensation.c LCD12864_Display_Menu_Delay_Inspection.c LCD12864_Display_Menu_Set_Time.c LCD12864_Display_Menu_Stroking_Cycle.c LCD12864_Display_Menu_Set_Strategy_Info.c
    ../HARDWARE/RELAY/: relay.c Check_Stroking_Cycle.c Monitor_IN1.c
    ../HARDWARE/HUMI/: HUMI.c
    ../HARDWARE/DELAY/: delay.c
    ../HARDWARE/24C0X/: IIC.c 24C0x.c
    ../HARDWARE/BUZZER/: BUZZER.c
    ../HARDWARE/ESP8266/: ESP8266.c HTTP_CODE.c
  group Application/User
    ../Src/: main.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c Strategy.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: uart.c
    ..//Src/: system_stm32f1xx.c
    ../Drivers/EDP/: EdpKit.c cJSON.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
software components: CMSIS:CORE 5.0.1
